# Keil uVision project BY_RT-Thread.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BY_RT-Thread
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  c include: ..\User;..\rtthread\3.0.3\bsp;..\rtthread\3.0.3\components\finsh;..\rtthread\3.0.3\include;..\rtthread\3.0.3\include\libc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../User/: main.c rtconfig.h
  group rtt/ports
    ../rtthread/3.0.3/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group rtt/source
    ../rtthread/3.0.3/include/: rtdef.h rtservice.h
    ../rtthread/3.0.3/src/: thread.c scheduler.c object.c kservice.c idle.c clock.c irq.c timer.c
  group doc
    ../Doc/: readm.txt
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
